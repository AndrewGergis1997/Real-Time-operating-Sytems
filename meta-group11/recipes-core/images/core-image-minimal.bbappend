IMAGE_INSTALL += "hello-mod"
